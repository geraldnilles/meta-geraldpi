
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "\
    file://squashfs.cfg \
    file://rtc.cfg \
"
